# Keil uVision project ADC_transmit_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_transmit_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_transmit_LCD.c delay.c delay.h LCD_4bit.c LCD_4bit.h uart.c uart.h ADC.c ADC.h
