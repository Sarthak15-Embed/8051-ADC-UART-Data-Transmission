# Keil uVision project ADC_Receievd_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_Receievd_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 ADC_Rececived_LCD.c ADC.c ADC.h delay.c delay.h LCD_4bit.c LCD_4bit.h uart.c uart.h
